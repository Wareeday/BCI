options:
  parameters:
    author: Warda Masood
    category: '[BCI Platform]'
    comment: |-
      GNU Radio DSP Flowgraph for BCI Platform
      OpenBCI → Bandpass → Notch → LSL Out
      Latency: <3ms per block at 250 Hz
      Sample rate: 250 Hz, 8 channels
    copyright: Al Nafi International College 2025
    description: Real-time EEG signal processing for BCI platform
    generate_options: qt_gui
    id: bci_eeg_pipeline
    output_language: python
    realtime_scheduling: '1'
    title: BCI EEG Real-Time DSP Pipeline
  states: {}

blocks:
- name: zeromq_pull_source
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    comment: |-
      Receives raw EEG float32 samples from
      Raspberry Pi edge gateway via ZeroMQ PUB/SUB.
      Format: 8 floats per message = one 8-channel sample.
    hwm: '100'
    timeout: '100'
    type: float
    vlen: '8'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Butterworth-equivalent FIR low-pass at 40 Hz.
      Combined with high-pass gives 1-40 Hz bandpass.
      Latency: <0.5ms at 250 Hz sample rate.
    cutoff_freq: '40'
    decim: '1'
    gain: '1'
    samp_rate: '250'
    type: fir_filter_fff
    width: '5'
    win: window.WIN_HAMMING
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    comment: High-pass at 1 Hz removes DC drift.
    cutoff_freq: '1'
    decim: '1'
    gain: '1'
    samp_rate: '250'
    type: fir_filter_fff
    width: '0.5'
    win: window.WIN_HAMMING
  states: {}
- name: iir_filter_0
  id: iir_filter
  parameters:
    comment: |-
      IIR notch filter at 50 Hz (EU powerline).
      For US deployments: change to 60 Hz.
      Q factor = 30 for narrow notch.
      Latency: <0.5ms.
    fbtaps: iir_design.design_notch(50.0/125.0, Q=30)[1]
    fftaps: iir_design.design_notch(50.0/125.0, Q=30)[0]
    new_taps_on_change: 'True'
    type: float
    vlen: '1'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5556
    comment: |-
      Publishes filtered EEG to Python DSP stage.
      Python handles ICA (FastICA) and ASR (MNE)
      because they require matrix operations not
      natively available in GNU Radio blocks.
    hwm: '100'
    timeout: '100'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Real-time EEG waveform display.
      Shows 8 channels overlaid.
      Used during electrode placement and QA.
    name: '"Live EEG (post-filter)"'
    nconnections: '8'
    size: '500'
    srate: '250'
    type: float
    update_time: '0.04'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    comment: |-
      PSD display. Verify:
      - Alpha peak at 8-13 Hz (Oz channel)
      - Notch at 50 Hz
      - Bandpass cutoff at 40 Hz
    fc: '0'
    fftsize: '256'
    name: '"EEG PSD"'
    showports: 'True'
    srate: '250'
    type: float
    update_time: '0.1'
  states: {}

connections:
- [zeromq_pull_source, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', iir_filter_0, '0']
- [iir_filter_0, '0', zeromq_push_sink_0, '0']
- [iir_filter_0, '0', qtgui_time_sink_x_0, '0']
- [iir_filter_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.7.0
